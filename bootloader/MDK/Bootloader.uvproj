# Keil uVision project Bootloader.uvproj, settings and files
target Bootloader (ARM-ADS)
  device: STM32F103VB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: SysTick +hex
  c flags: Optim=1
  c define: STM32F10X_HD
  c include: ..\Driver;..\System;..\User;..\System\usart;..\Device;..\vshell;..\vshell\bsp;..\vshell\src;..\Xmodem;..\Xmodem\bsp;..\Xmodem\src;..\vshell\src\command;..\IAP;..\MDK
  memory RVCT4: ROM 0x8000000 size 0x9000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group System
    ../System/: core_cm3.c core_cm3.h startup_stm32f10x_hd.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ../User/: main.c
  group Driver
    ../Driver/: bsp_flash.c bsp_systick.c bsp_usart1.c
  group IAP
    ../IAP/: iap.c iap.h
  group Xmodem
    ../Xmodem/src/: Xmodem.c
    ../Xmodem/bsp/: Xmodem_io.c Xmodem_bsp.c
  group Shell_src
    ../vshell/src/: vshell.c vshell_io.c
    ../vshell/bsp/: bsp.c
  group Shell_cmd
    ../vshell/src/: vshell_list.c
    ../vshell/src/command/: cmd_help.c cmd_version.c cmd_xmodem.c cmd_boot.c
  group Shell_cfg
    ../vshell/src/: shell_config.h
